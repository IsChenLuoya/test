# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h Nixie.c Nixie.h Key.c Key.h Buzzer.c Buzzer.h
